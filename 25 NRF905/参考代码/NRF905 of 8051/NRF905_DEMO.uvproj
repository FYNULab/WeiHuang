# Keil uVision project NRF905_DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: NRF905_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    E:/产品开发/模块/NRF905/NRF905无线数传模块资料/参考代码/NRF905 of 8051/: STARTUP.A51
    ./: main.c
