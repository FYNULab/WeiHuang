# Keil uVision project EX4 SD_PIC_SHOW.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: EX4 SD_PIC_SHOW +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SD.C SD.H main.c NBCTFT.C NBCTFT.H
