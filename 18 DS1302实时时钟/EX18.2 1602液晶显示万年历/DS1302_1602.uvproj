# Keil uVision project DS1302_1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: DS1302_1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 1602.c ds1302.c
