<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EX4 SD_PIC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


