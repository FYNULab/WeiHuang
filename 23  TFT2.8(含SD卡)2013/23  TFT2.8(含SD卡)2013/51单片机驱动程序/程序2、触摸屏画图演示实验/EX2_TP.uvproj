# Keil uVision project EX2_TP.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: EX2_TP +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c NBCTFT.C Ascii_8x16.h NBCTFT.H chinese.h TP.C TP.H
