# Keil uVision project Light_smg.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: Light_smg +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c PCF8591.c
